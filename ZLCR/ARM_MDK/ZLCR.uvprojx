# Keil uVision project ZLCR.uvprojx, settings and files
target EASY_USB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ZLCR +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F401xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\USER;..\CORE;..\HARDWARE;..\SYS;..\LCR
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c
  group LCR
    ../LCR/: LCR_core.c
  group HARDWARE
    ../HARDWARE/: LCD.c I2C.c AIC3204.c EEPROM24C.c
  group CORE
    ../CORE/: startup_stm32f401xx.s system_stm32f4xx.c arm_cortexM4lf_math.lib
  group SYS
    ../SYS/: delay.c sys.c stm32f4xx_it.c usart.c
